#include "types.h"
#include "assist.h"

const int16u crc_ccitt[256]={
0x0000, 0x1021, 0x2042, 0x3063, 0x4084, 0x50a5, 0x60c6, 0x70e7,
0x8108, 0x9129, 0xa14a, 0xb16b, 0xc18c, 0xd1ad, 0xe1ce, 0xf1ef,
0x1231, 0x0210, 0x3273, 0x2252, 0x52b5, 0x4294, 0x72f7, 0x62d6,
0x9339, 0x8318, 0xb37b, 0xa35a, 0xd3bd, 0xc39c, 0xf3ff, 0xe3de,
0x2462, 0x3443, 0x0420, 0x1401, 0x64e6, 0x74c7, 0x44a4, 0x5485,
0xa56a, 0xb54b, 0x8528, 0x9509, 0xe5ee, 0xf5cf, 0xc5ac, 0xd58d,
0x3653, 0x2672, 0x1611, 0x0630, 0x76d7, 0x66f6, 0x5695, 0x46b4,
0xb75b, 0xa77a, 0x9719, 0x8738, 0xf7df, 0xe7fe, 0xd79d, 0xc7bc,
0x48c4, 0x58e5, 0x6886, 0x78a7, 0x0840, 0x1861, 0x2802, 0x3823,
0xc9cc, 0xd9ed, 0xe98e, 0xf9af, 0x8948, 0x9969, 0xa90a, 0xb92b,
0x5af5, 0x4ad4, 0x7ab7, 0x6a96, 0x1a71, 0x0a50, 0x3a33, 0x2a12,
0xdbfd, 0xcbdc, 0xfbbf, 0xeb9e, 0x9b79, 0x8b58, 0xbb3b, 0xab1a,
0x6ca6, 0x7c87, 0x4ce4, 0x5cc5, 0x2c22, 0x3c03, 0x0c60, 0x1c41,
0xedae, 0xfd8f, 0xcdec, 0xddcd, 0xad2a, 0xbd0b, 0x8d68, 0x9d49,
0x7e97, 0x6eb6, 0x5ed5, 0x4ef4, 0x3e13, 0x2e32, 0x1e51, 0x0e70,
0xff9f, 0xefbe, 0xdfdd, 0xcffc, 0xbf1b, 0xaf3a, 0x9f59, 0x8f78,
0x9188, 0x81a9, 0xb1ca, 0xa1eb, 0xd10c, 0xc12d, 0xf14e, 0xe16f,
0x1080, 0x00a1, 0x30c2, 0x20e3, 0x5004, 0x4025, 0x7046, 0x6067,
0x83b9, 0x9398, 0xa3fb, 0xb3da, 0xc33d, 0xd31c, 0xe37f, 0xf35e,
0x02b1, 0x1290, 0x22f3, 0x32d2, 0x4235, 0x5214, 0x6277, 0x7256,
0xb5ea, 0xa5cb, 0x95a8, 0x8589, 0xf56e, 0xe54f, 0xd52c, 0xc50d,
0x34e2, 0x24c3, 0x14a0, 0x0481, 0x7466, 0x6447, 0x5424, 0x4405,
0xa7db, 0xb7fa, 0x8799, 0x97b8, 0xe75f, 0xf77e, 0xc71d, 0xd73c,
0x26d3, 0x36f2, 0x0691, 0x16b0, 0x6657, 0x7676, 0x4615, 0x5634,
0xd94c, 0xc96d, 0xf90e, 0xe92f, 0x99c8, 0x89e9, 0xb98a, 0xa9ab,
0x5844, 0x4865, 0x7806, 0x6827, 0x18c0, 0x08e1, 0x3882, 0x28a3,
0xcb7d, 0xdb5c, 0xeb3f, 0xfb1e, 0x8bf9, 0x9bd8, 0xabbb, 0xbb9a,
0x4a75, 0x5a54, 0x6a37, 0x7a16, 0x0af1, 0x1ad0, 0x2ab3, 0x3a92,
0xfd2e, 0xed0f, 0xdd6c, 0xcd4d, 0xbdaa, 0xad8b, 0x9de8, 0x8dc9,
0x7c26, 0x6c07, 0x5c64, 0x4c45, 0x3ca2, 0x2c83, 0x1ce0, 0x0cc1,
0xef1f, 0xff3e, 0xcf5d, 0xdf7c, 0xaf9b, 0xbfba, 0x8fd9, 0x9ff8,
0x6e17, 0x7e36, 0x4e55, 0x5e74, 0x2e93, 0x3eb2, 0x0ed1, 0x1ef0
};
int16u crc16_ccitt(void *pBuff, int32u len) {
    int32u crc;
    int8u da;
		int8u* p=(int8u*)pBuff;
    crc=0;
    while(len) {
        len--;
        da=(unsigned char) (crc/256);
        crc<<=8;
        crc^=crc_ccitt[da^*p];
        p++;
    }
    return(crc);
}

int16u crc16_ccitt_l(int8u *pBuff, int32u len) {
    int16u crc16;
    int8u crc_l, crc_h;
    int8u da;
		int32u i;
    crc16 = 0;
    for (i = 0; i < len; i++) {
        da = (crc16 / 256);
        crc16 <<= 8;
        crc16 ^= crc_ccitt[da ^ reverse_bits(pBuff[i])];
    }

    crc_h = reverse_bits((int8u)crc16);
    crc_l = reverse_bits((int8u)(crc16 >> 8));
    return crc_l + crc_h * 256;
}

int16u crc16_typea(int8u* pBuff, int32u dwLen)
{
    int8u ch;
    int16u wCrc;
		int32u i;
    wCrc = 0x6363; /* ITU-V.41 */
    for(i=0;i<dwLen;i++){
        ch = pBuff[i];
        ch ^= (int8u)(wCrc);
        ch ^= (int8u)(ch<<4);
        wCrc = (wCrc>> 8)^((int16u)ch<<8)^((int16u)ch<<3)^((int16u)ch>>4);
    }
    return wCrc;
}


uint16_t crc16_ibm(void* dat, int len)
{
	uint16_t i, j;
	uint8_t* data=(uint8_t*)dat;
	uint16_t crc = 0XFFFF;
		for (i = 0; i < len; i++)
		{
				crc ^= data[i];
				for (j = 0; j < 8; j++)
				{
						if ((crc & 0X01) == 1)
								crc = (crc >> 1) ^ 0xA001;
						else
								crc = crc >> 1;
				}

		}
		return crc;
}
				
				
const char HEXCHAR[]={'0','1','2','3','4','5','6','7','8','9','A','B','C','D','E','F'};
void bin2hex(int8u* pBuff,int32u nCount,char* pTagNo){
    int32u i;
    for(i=0;i<nCount;i++){
        pTagNo[i*2]=HEXCHAR[pBuff[i]/0x10];
        pTagNo[i*2+1]=HEXCHAR[pBuff[i]%0x10];
    }
    pTagNo[2*nCount]=0;
}
int8u hex2byte(const char* pCh){
    int8u bytVal;
    int8u retVal;

    bytVal=(int8u)pCh[0];
    if(bytVal>='0' && bytVal<='9')
        bytVal=bytVal- '0';
    else if(bytVal>='A' && bytVal<='F')
        bytVal=bytVal- 'A' + 10;
    else if(bytVal>='a' && bytVal<='f')
        bytVal=bytVal- 'a' + 10;
    retVal=((int8u)bytVal) << 4 ;

    bytVal=(int8u)pCh[1];
    if(bytVal>='0' && bytVal<='9')
        bytVal=bytVal- '0';
    else if(bytVal>='A' && bytVal<='F')
        bytVal=bytVal- 'A' + 10;
    else if(bytVal>='a' && bytVal<='f')
        bytVal=bytVal- 'a' + 10;

    retVal+=bytVal;
    return retVal;
}

int32u hex2bin(const char* pTagNo,int8u* pBuff,int32u nMaxCount){
    int32u i;
    int8u bytVal_h,bytVal_l;
    char ch;
    for(i=0;i<nMaxCount;i++){
        ch=(char)pTagNo[0+i*2];
        if(	(ch>='0') && (ch<='9') ){
            bytVal_h=ch-'0';
        }else if(ch>='A' && ch<='F'){
            bytVal_h=ch-'A'+10;
        }else if(ch>='a' && ch<='f'){
            bytVal_h=ch-'a'+10;
        }else{
            return i;
        }

        ch=(char)pTagNo[1+i*2];
        if(	(ch>='0') && (ch<='9') ){
            bytVal_l=ch-'0';
        }else if(ch>='A' && ch<='F'){
            bytVal_l=ch-'A'+10;
        }else if(ch>='a' && ch<='f'){
            bytVal_l=ch-'a'+10;
        }else{
            return i;
        }

        pBuff[i]=bytVal_h*0x10+bytVal_l;
    }
    return nMaxCount;

}

int8u reverse_bits(int8u bytIn){
    int8u bytResult=0;
    if(bytIn & 0x01){
        bytResult|=0x80;
    }
    if(bytIn & 0x02){
        bytResult|=0x40;
    }
    if(bytIn & 0x04){
        bytResult|=0x20;
    }
    if(bytIn & 0x08){
        bytResult|=0x10;
    }
    if(bytIn & 0x10){
        bytResult|=0x08;
    }
    if(bytIn & 0x20){
        bytResult|=0x04;
    }
    if(bytIn & 0x40){
        bytResult|=0x02;
    }
    if(bytIn & 0x80){
        bytResult|=0x01;
    }
    return bytResult;
}

static const int8u CRC8TABLE[256]={0x00,0x1D,0x3A,0x27,0x74,0x69,0x4E,0x53,0xE8,0xF5,0xD2,0xCF,0x9C,0x81,0xA6,0xBB,
                        0xCD,0xD0,0xF7,0xEA,0xB9,0xA4,0x83,0x9E,0x25,0x38,0x1F,0x02,0x51,0x4C,0x6B,0x76,
                        0x87,0x9A,0xBD,0xA0,0xF3,0xEE,0xC9,0xD4,0x6F,0x72,0x55,0x48,0x1B,0x06,0x21,0x3C,
                        0x4A,0x57,0x70,0x6D,0x3E,0x23,0x04,0x19,0xA2,0xBF,0x98,0x85,0xD6,0xCB,0xEC,0xF1,
                        0x13,0x0E,0x29,0x34,0x67,0x7A,0x5D,0x40,0xFB,0xE6,0xC1,0xDC,0x8F,0x92,0xB5,0xA8,
                        0xDE,0xC3,0xE4,0xF9,0xAA,0xB7,0x90,0x8D,0x36,0x2B,0x0C,0x11,0x42,0x5F,0x78,0x65,
                        0x94,0x89,0xAE,0xB3,0xE0,0xFD,0xDA,0xC7,0x7C,0x61,0x46,0x5B,0x08,0x15,0x32,0x2F,
                        0x59,0x44,0x63,0x7E,0x2D,0x30,0x17,0x0A,0xB1,0xAC,0x8B,0x96,0xC5,0xD8,0xFF,0xE2,
                        0x26,0x3B,0x1C,0x01,0x52,0x4F,0x68,0x75,0xCE,0xD3,0xF4,0xE9,0xBA,0xA7,0x80,0x9D,
                        0xEB,0xF6,0xD1,0xCC,0x9F,0x82,0xA5,0xB8,0x03,0x1E,0x39,0x24,0x77,0x6A,0x4D,0x50,
                        0xA1,0xBC,0x9B,0x86,0xD5,0xC8,0xEF,0xF2,0x49,0x54,0x73,0x6E,0x3D,0x20,0x07,0x1A,
                        0x6C,0x71,0x56,0x4B,0x18,0x05,0x22,0x3F,0x84,0x99,0xBE,0xA3,0xF0,0xED,0xCA,0xD7,
                        0x35,0x28,0x0F,0x12,0x41,0x5C,0x7B,0x66,0xDD,0xC0,0xE7,0xFA,0xA9,0xB4,0x93,0x8E,
                        0xF8,0xE5,0xC2,0xDF,0x8C,0x91,0xB6,0xAB,0x10,0x0D,0x2A,0x37,0x64,0x79,0x5E,0x43,
                        0xB2,0xAF,0x88,0x95,0xC6,0xDB,0xFC,0xE1,0x5A,0x47,0x60,0x7D,0x2E,0x33,0x14,0x09,
                        0x7F,0x62,0x45,0x58,0x0B,0x16,0x31,0x2C,0x97,0x8A,0xAD,0xB0,0xE3,0xFE,0xD9,0xC4
    };
int8u crc8_ccitt(int8u preset,void * pBuff,int32u nCount)
{

    int32u i;
    int8u crc=preset;
    int8u* p_data=(int8u*)pBuff;
    for (i=0;i<nCount;i++)
        crc=CRC8TABLE[crc^p_data[i]];
    return crc;
}

static const int8u mb_crc_hi[] = {
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
    0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 
    0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40
};

static const int8u mb_crc_lo[] = {
    0x00, 0xC0, 0xC1, 0x01, 0xC3, 0x03, 0x02, 0xC2, 0xC6, 0x06, 0x07, 0xC7,
    0x05, 0xC5, 0xC4, 0x04, 0xCC, 0x0C, 0x0D, 0xCD, 0x0F, 0xCF, 0xCE, 0x0E,
    0x0A, 0xCA, 0xCB, 0x0B, 0xC9, 0x09, 0x08, 0xC8, 0xD8, 0x18, 0x19, 0xD9,
    0x1B, 0xDB, 0xDA, 0x1A, 0x1E, 0xDE, 0xDF, 0x1F, 0xDD, 0x1D, 0x1C, 0xDC,
    0x14, 0xD4, 0xD5, 0x15, 0xD7, 0x17, 0x16, 0xD6, 0xD2, 0x12, 0x13, 0xD3,
    0x11, 0xD1, 0xD0, 0x10, 0xF0, 0x30, 0x31, 0xF1, 0x33, 0xF3, 0xF2, 0x32,
    0x36, 0xF6, 0xF7, 0x37, 0xF5, 0x35, 0x34, 0xF4, 0x3C, 0xFC, 0xFD, 0x3D,
    0xFF, 0x3F, 0x3E, 0xFE, 0xFA, 0x3A, 0x3B, 0xFB, 0x39, 0xF9, 0xF8, 0x38, 
    0x28, 0xE8, 0xE9, 0x29, 0xEB, 0x2B, 0x2A, 0xEA, 0xEE, 0x2E, 0x2F, 0xEF,
    0x2D, 0xED, 0xEC, 0x2C, 0xE4, 0x24, 0x25, 0xE5, 0x27, 0xE7, 0xE6, 0x26,
    0x22, 0xE2, 0xE3, 0x23, 0xE1, 0x21, 0x20, 0xE0, 0xA0, 0x60, 0x61, 0xA1,
    0x63, 0xA3, 0xA2, 0x62, 0x66, 0xA6, 0xA7, 0x67, 0xA5, 0x65, 0x64, 0xA4,
    0x6C, 0xAC, 0xAD, 0x6D, 0xAF, 0x6F, 0x6E, 0xAE, 0xAA, 0x6A, 0x6B, 0xAB, 
    0x69, 0xA9, 0xA8, 0x68, 0x78, 0xB8, 0xB9, 0x79, 0xBB, 0x7B, 0x7A, 0xBA,
    0xBE, 0x7E, 0x7F, 0xBF, 0x7D, 0xBD, 0xBC, 0x7C, 0xB4, 0x74, 0x75, 0xB5,
    0x77, 0xB7, 0xB6, 0x76, 0x72, 0xB2, 0xB3, 0x73, 0xB1, 0x71, 0x70, 0xB0,
    0x50, 0x90, 0x91, 0x51, 0x93, 0x53, 0x52, 0x92, 0x96, 0x56, 0x57, 0x97,
    0x55, 0x95, 0x94, 0x54, 0x9C, 0x5C, 0x5D, 0x9D, 0x5F, 0x9F, 0x9E, 0x5E,
    0x5A, 0x9A, 0x9B, 0x5B, 0x99, 0x59, 0x58, 0x98, 0x88, 0x48, 0x49, 0x89,
    0x4B, 0x8B, 0x8A, 0x4A, 0x4E, 0x8E, 0x8F, 0x4F, 0x8D, 0x4D, 0x4C, 0x8C,
    0x44, 0x84, 0x85, 0x45, 0x87, 0x47, 0x46, 0x86, 0x82, 0x42, 0x43, 0x83,
    0x41, 0x81, 0x80, 0x40
};

int16u mb_crc16( int8u * data, int16u len )
{
    int8u           crc_hi = 0xFF;
    int8u           crc_lo = 0xFF;
    int             i;

    while( len-- )
    {
        i = crc_lo ^ *( data++ );
        crc_lo = ( UCHAR )( crc_hi ^ mb_crc_hi[i] );
        crc_hi = mb_crc_lo[i];
    }
    return ( int16u )( crc_hi << 8 | crc_lo );
}


///////////////////////////////?????////////////////////////////////////////
//const int8u s_month_days[]={31,28,31,30,31,30,31,31,30,31,30,31};
//const int8u s_month_days_r[]={31,29,31,30,31,30,31,31,30,31,30,31};

//void ajustTime(DATETIME* pDateTime){
//    pDateTime->year%=50;
//    if(pDateTime->month==0){
//        pDateTime->month=12;
//    }else if(pDateTime->month>12){
//        pDateTime->month=1;
//    }

//    if( pDateTime->year%4==0 ){
//        if(pDateTime->day==0){
//            pDateTime->day=s_month_days_r[pDateTime->month-1];
//        }else if(pDateTime->day>s_month_days_r[pDateTime->month-1]){
//            pDateTime->day=1;
//        }
//    }else{
//        if(pDateTime->day==0){
//            pDateTime->day=s_month_days[pDateTime->month-1];
//        }else if(pDateTime->day>s_month_days[pDateTime->month-1]){
//            pDateTime->day=1;
//        }
//    }
//    pDateTime->hour%=24;
//    pDateTime->minute%=60;
//    pDateTime->second%=60;
//}

////??????????????????
////1??1?? ??? 0
////12??31?? ??? 364
//int32u toDays(int8u nYear,int8u nMonth,int8u nDay){
//	int32u nDays,i;
//	nDays=0;
//	if(nYear%4==0){//????
//		for(i=1;i<nMonth;i++){
//			nDays+=s_month_days_r[i-1];
//		}
//	}else{
//		for(i=1;i<nMonth;i++){
//			nDays+=s_month_days[i-1];
//		}
//	}
//	nDays+=nDay-1;
//	return nDays;
//}

////0   ???2000-1-1(????)
////366 ???2001-1-1
//int8u parseYear(int8u nStartYear,int32u* pDays){
//	int8u nYear;
//	
//	nYear=nStartYear;
//	while(nYear<100){
//		if(nYear%4==0){
//			if( *pDays<366){
//				return nYear;
//			}else{
//				*pDays-=366;
//				nYear++;
//			}
//		}else{
//			if( *pDays<365 ){
//				return nYear;
//			}else{
//				*pDays-=365;
//				nYear++;
//			}
//		}
//	}
//	return nYear;
//}

//int8u parseMonth(int8u nYear,int32u* pYearDays){
//	int i;
//	if(nYear%4==0){
//		for(i=0;i<12;i++){
//			if(*pYearDays<s_month_days_r[i]){
//				return i+1;
//			}else{
//				*pYearDays-=s_month_days_r[i];
//			}
//		}
//	}else{
//		for(i=0;i<12;i++){
//			if(*pYearDays<s_month_days[i]){
//				return i+1;
//			}else{
//				*pYearDays-=s_month_days[i];
//			}
//		}
//	}
//	return 1;
//}

//int32u timeToSeconds(DATETIME* pTm){
//    int32u _seconds;
//    int32u _days;

//    _days=pTm->year*365+(pTm->year+3)/4;
//	_days+=toDays(pTm->year,pTm->month,pTm->day);
//	_seconds=pTm->hour*3600+pTm->minute*60+pTm->second;
//    return _seconds + _days*3600*24;
//}

//void secondsToTime(int32u seconds,DATETIME* pTm){
//	int32u nDayCount;
//	
//	nDayCount= seconds/(3600*24);
//	pTm->year=parseYear(0,&nDayCount);
//	pTm->month=parseMonth(pTm->year,&nDayCount);
//	pTm->day=nDayCount+1;
//	
//	seconds %= (24*60*60);
//	pTm->hour =seconds/(60*60);
//	seconds %= (60*60);
//	pTm->minute =seconds/(60);
//	seconds %= (60);
//	pTm->second =seconds;
//}




//strchr 查找给定字符的第一个出现位置,找不到就返回0
//strtol 字符串转long
BOOL parse_ip_string(string ip_str,int8u* ip)
{
	char ip_item[4];
	char* dot,*end,*p_parse=(char*)ip_str;
	int i;
	if(!ip_str)
		return FALSE;
	for(i=0;i<4;i++)
	{
		if(i<3)
		{
			dot=strchr(p_parse,'.');//查找.的位置
			if(!dot)
				return FALSE;
			*dot=0;
		}
		strcpy(ip_item,p_parse);//拷贝数字字符串到item，待分析
		if(ip)
			ip[3-i]= strtol(ip_item,&end,10);
		if(end!=ip_item+strlen(ip_item))//说明含有非数字
			return FALSE;
		p_parse=dot+1;
	}
	return TRUE;
}


int32u  parse_u32(String pdata,int8u size)
{
    int32u ret=0,temp=0;
    int8u  i;

    for(i=0;i<size;i++){
        if((pdata[i]>='0')&&(pdata[i]<='9'))
		{
            temp=(pdata[i]-'0');
        }
		else  if((pdata[i]>='A')&&(pdata[i]<='F'))
		{
            temp=(pdata[i]-'A'+10);
        }
		else if((pdata[i]>='a')&&(pdata[i]<='f'))
		{
            temp=(pdata[i]-'a'+10);;
        }
		else
			break;
        ret=10*ret+temp;
    }
    return ret;
}

