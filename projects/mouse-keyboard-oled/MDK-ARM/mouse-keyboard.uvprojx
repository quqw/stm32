# Keil uVision project mouse-keyboard.uvprojx, settings and files
target STM32-MD (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mouse_keypad +hex
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD,__DEBUG
  c include: ..\..\..\stm32_f1\Libraries\CMSIS\Include;..\..\..\stm32_f1\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\..\stm32_f1\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\..\stm32_f1\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\user_src;..\..\..\stm32_f1;..\src;..\src\usb
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../src/: main.c stm32_it.c cmd.c system_stm32f10x.c
  group CMSIS
    ../../../stm32_f1/Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd.s startup_stm32f10x_hd_freertos.s startup_stm32f10x_md.s startup_stm32f10x_md_freertos.s
  group USB-FS-Device_Driver
    ../../../stm32_f1/Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STM32F10x_StdPeriph_Driver
    ../../../stm32_f1/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group board
    ../src/board/: board.c
  group usb
    ../src/usb/: usb_conf.h usb_desc.c usb_desc.h usb_endp.c usb_istr.c usb_istr.h usb_prop.c usb_prop.h usb_pwr.c usb_pwr.h usb_hw.c usb_func.c usb_func.h usb_hw.h
  group communication
    ../../../user_src/communication/: comm_app.c serial_transfer.c usb_transfer.c
  group assist
    ../src/assist/: assist.c assist.h
    ../../../user_src/assist/: ByteQueue.c ByteQueue.h delay.c delay.h
  group platform_drivers
    ../../../stm32_f1/platform_drivers/: st_gpio.c st_uart.c st_timer.h st_uart.h st_gpio.h
software components: CMSIS:CORE 4.3.0
