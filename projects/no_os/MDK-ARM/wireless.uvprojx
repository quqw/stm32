# Keil uVision project wireless.uvprojx, settings and files
target STM3210-MD (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM3210-MD
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, USE_STM3210B_EVAL
  c include: ..\..\..\stm32_f1\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\..\stm32_f1\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\..\stm32_f1\Libraries\STM32F10x_StdPeriph_Driver\inc;..\src;..\src\usb;..\..\..\FreeRTOS\Source\include;..\..\..\FreeRTOS\Source\portable\MemMang;..\..\..\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\..\user_src;..\..\..\stm32_f1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../src/: main.c stm32_it.c board.c board.h stm32f10x_conf.h
    ../../../stm32_f1/platform/: delay.c
  group CMSIS
    ../src/: system_stm32f10x.c
    ../../../stm32_f1/Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd.s startup_stm32f10x_md.s
  group STM32F10x_StdPeriph_Driver
    ../../../stm32_f1/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group assist
    ../../../user_src/assist/: ByteQueue.c
target STM3210-HD (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mouse_keypad +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210E_EVAL
  c include: ..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\..\stm32-3.6;..\src;..\src\usb
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
software components: CMSIS:CORE 4.3.0
