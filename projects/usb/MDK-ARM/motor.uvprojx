# Keil uVision project motor.uvprojx, settings and files
target STM3210-MD_RELEASE (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM3210-MD +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD,
  c include: ..\..\..\stm32_f1\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\..\stm32_f1\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\..\stm32_f1\Libraries\STM32F10x_StdPeriph_Driver\inc;..\src;..\src\usb;..\..\..\FreeRTOS\Source\include;..\..\..\FreeRTOS\Source\portable\MemMang;..\..\..\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\..\user_src;..\..\..\stm32_f1\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../src/: main.c stm32_it.c cmd.c FreeRTOSConfig.h exception.c exception.h config.h system_stm32f10x.c
    ../../../stm32_f1/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c
  group CMSIS
    ../src/: system_stm32f10x.c
    ../../../stm32_f1/Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd_freertos.s startup_stm32f10x_md_freertos.s startup_stm32f10x_hd.s startup_stm32f10x_md.s
  group USB-FS-Device_Driver
    ../../../stm32_f1/Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STM32F10x_StdPeriph_Driver
    ../../../stm32_f1/Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group platform
    ../../../stm32_f1/platform/: ad.c delay.c gpio.c gpio_bus.c i2c.c io8080.c timer.c uart.c pwm.c
  group board
    ../src/board/: board.c board.h
  group usb
    ../src/usb/: usb_conf.h usb_desc.c usb_desc.h usb_endp.c usb_istr.c usb_istr.h usb_prop.c usb_prop.h usb_pwr.c usb_pwr.h usb_hw.c usb_func.c usb_func.h usb_hw.h
  group communication
    ../../../user_src/communication/: comm_app.c comm_app.h comm_types.h serial_transfer.c serial_transfer.h usb_transfer.c usb_transfer.h
  group assist
    ../../../user_src/assist/: assist.c assist.h
  group drivers
    ../../../user_src/drivers/: led.c led.h
  group KeyBoard
    ../../../user_src/drivers/KeyBoard/: KeyBoard.c KeyBoard.h
  group FreeRTOS
    ../../../FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c portmacro.h
    ../../../FreeRTOS/Source/portable/MemMang/: heap_1.c heap_2.c heap_3.c
target STM3210-MD_DEBUG (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM3210-MD
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD,__DEBUG
  c include: ..\..\..\stm32_f1\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\..\stm32_f1\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\..\stm32_f1\Libraries\STM32F10x_StdPeriph_Driver\inc;..\src;..\src\usb;..\..\..\FreeRTOS\Source\include;..\..\..\FreeRTOS\Source\portable\MemMang;..\..\..\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\..\user_src;..\..\..\stm32_f1
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 4.3.0
